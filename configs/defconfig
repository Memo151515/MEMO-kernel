## configs/defconfig
```kconfig
ARCH=i386
CONFIG_SERIAL=y
CONFIG_PCI=y
CONFIG_ATA=y
CONFIG_RTC=y
KEYMAP=tr
CONFIG_DEBUG=n
```
